# gstreamer hits the g_once_init_enter() pointer problem
PACKAGECONFIG:remove = "gstreamer"
