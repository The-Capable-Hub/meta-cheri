RDEPENDS:${PN}:remove = "kernel-module-mdio-netlink"
