# mozjs requires rust
PACKAGECONFIG:remove = "mozjs"
PACKAGECONFIG:append = "duktape"
