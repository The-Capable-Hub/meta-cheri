require gdb-cheri-common.inc

DEPENDS += "bison-native"
