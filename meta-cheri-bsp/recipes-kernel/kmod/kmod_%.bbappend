FILESEXTRAPATHS:prepend := "${THISDIR}/kmod:"
SRC_URI += " \
    file://alignment.patch \
"

