RDEPENDS:${PN}-routel:remove = "python3-core"
