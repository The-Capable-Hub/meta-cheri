FILESEXTRAPATHS:prepend := "${THISDIR}/files:"
SRC_URI += " \
    file://cheri-setproctitle.patch \
"
