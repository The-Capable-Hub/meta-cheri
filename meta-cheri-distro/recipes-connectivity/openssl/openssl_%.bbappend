EXTRA_OECONF:append:cheri = " no-asm"
