EXTRA_OECONF:append = " \
    --enable-sshd \
    --enable-shell \
    --enable-sftp \
    --enable-sshclient \
"
