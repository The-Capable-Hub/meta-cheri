FILESEXTRAPATHS:prepend := "${THISDIR}/kbd:"
SRC_URI += " \
    file://musl-cheri-timer.patch \
"
