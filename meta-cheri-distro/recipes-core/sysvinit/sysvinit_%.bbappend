FILESEXTRAPATHS:prepend := "${THISDIR}/sysvinit:"
SRC_URI += " \
	file://cheri_fixes.patch \
"
