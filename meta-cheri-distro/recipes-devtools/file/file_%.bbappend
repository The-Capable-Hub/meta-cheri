PACKAGECONFIG:remove = "zstdlib"
