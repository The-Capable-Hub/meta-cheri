FILESEXTRAPATHS:prepend := "${THISDIR}/files:"
 
SRC_URI:append = " \
    file://0001-cheri-perl-cross.patch \
"

