# package-managemtn requires rpm, which requires zstd
IMAGE_FEATURES:remove = "package-management"
