IMAGE_FEATURES:remove = "package-management hwcodecs"
