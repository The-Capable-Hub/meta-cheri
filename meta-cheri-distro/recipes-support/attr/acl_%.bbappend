FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"
SRC_URI += "file://libobj-fix-ext2int-on-arches-with-16-byte-pointer.patch"
