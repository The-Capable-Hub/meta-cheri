FILESEXTRAPATHS:prepend := "${THISDIR}/glib-2.0:"
SRC_URI += " \
    file://cheribsd.patch;striplevel=0 \
"
