LDFLAGS:append:cheri = " -static -v"