FILESEXTRAPATHS:prepend := "${THISDIR}/eudev:"
SRC_URI += " \
    file://cheri-fixes.patch \
"
