FILESEXTRAPATHS:prepend := "${THISDIR}/cpio:"
SRC_URI += " \
    file://Redirect-cheri.h-to-cheriintrin.h.patch \
"
