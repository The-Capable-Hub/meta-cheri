PACKAGECONFIG:remove = "zstd"
