RDEPENDS:${PN}:remove:cheri = "python3-xml"

