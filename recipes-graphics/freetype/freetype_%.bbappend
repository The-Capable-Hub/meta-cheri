FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI:append = " \
	file://0001-ftraster-use-capabilites-in-profile-buffer.patch \
"
