# This pulls in python (via vte, vala and gobject-introspection)
RDEPENDS:${PN}:remove = "matchbox-terminal"
