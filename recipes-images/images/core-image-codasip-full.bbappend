NON_CHERI_IMAGE_FEATURES = ""
NON_CHERI_IMAGE_INSTALL = ""
IMAGE_INSTALL:append:cheri = " \
    cheri-examples \
"
