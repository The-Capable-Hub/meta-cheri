EXTRA_OECONF:append = " --enable-assembly=no"
